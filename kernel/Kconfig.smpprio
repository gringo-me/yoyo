## kernel/Kconfig.smpprio
```kconfig
config SMP_PRIO
bool "sets one priority per processor"
default y
help
"sets smp priorities given a process id"
```
